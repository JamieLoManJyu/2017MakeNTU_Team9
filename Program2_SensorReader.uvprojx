# Keil uVision project Program2_SensorReader.uvprojx, settings and files
target Program2_SensorReader (ARM-ADS)
  device: STM32F429ZI STMicroelectronics
  pack: Keil.STM32F4xx_DFP.pdsc
  output: Program2_SensorReader
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD --preinclude=mbed_config.h -DMBED_BUILD_TIMESTAMP=1488078509.26 -DFEATURE_LWIP=1 -DTARGET_STM32F4 -D__ASSERT_MSG -DTARGET_RELEASE --no_rtti -Otime -DDEVICE_PORTINOUT=1 -DDEVICE_SERIAL_FC=1 -DDEVICE_I2C_ASYNCH=1 -DTARGET_FF_ARDUINO -c -DTARGET_RTOS_M4_M7 -O3 -DTARGET_STM32F429xx -DDEVICE_CAN=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 --split_sections -DTARGET_NUCLEO_F429ZI --cpu=Cortex-M4.fp -DDEVICE_SERIAL=1 -DDEVICE_ANALOGIN=1 -DTARGET_LIKE_CORTEX_M4 -DTARGET_STM32F429 -DDEVICE_ERROR_RED=1 -DTARGET_CORTEX_M -DARM_MATH_CM4 -DUSB_STM_HAL -DTARGET_STM32F429ZI -DTARGET_F429_F439 -DDEVICE_I2C=1 -D__CORTEX_M4 -DDEVICE_LOWPOWERTIMER=1 -DTARGET_STM -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu -DDEVICE_TRNG=1 --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DDEVICE_SPISLAVE=1 -DDEVICE_PORTIN=1 -DTARGET_M4 -D__FPU_PRESENT=1 -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -DDEVICE_SPI_ASYNCH=1 -DTRANSACTION_QUEUE_SIZE_SPI=2 -D__MBED_CMSIS_RTOS_CM
  c include: .; X_NUCLEO_IKS01A2; X_NUCLEO_IKS01A2/Components; X_NUCLEO_IKS01A2/Components/HTS221Sensor; X_NUCLEO_IKS01A2/Components/LPS22HBSensor; X_NUCLEO_IKS01A2/Components/LSM303AGRSensor; X_NUCLEO_IKS01A2/Components/LSM6DSLSensor; X_NUCLEO_IKS01A2/ST_INTERFACES; X_NUCLEO_IKS01A2/ST_INTERFACES/Actuators; X_NUCLEO_IKS01A2/ST_INTERFACES/Common; X_NUCLEO_IKS01A2/ST_INTERFACES/Communications; X_NUCLEO_IKS01A2/ST_INTERFACES/Sensors; X_NUCLEO_IKS01A2/X_NUCLEO_COMMON; X_NUCLEO_IKS01A2/X_NUCLEO_COMMON/DbgMCU; X_NUCLEO_IKS01A2/X_NUCLEO_COMMON/DevI2C; X_NUCLEO_IKS01A2/X_NUCLEO_COMMON/DevSPI; SB1602E; mbed/.; mbed/TARGET_NUCLEO_F429ZI; mbed/TARGET_NUCLEO_F429ZI/TARGET_STM; mbed/TARGET_NUCLEO_F429ZI/TARGET_STM/TARGET_STM32F4; mbed/TARGET_NUCLEO_F429ZI/TARGET_STM/TARGET_STM32F4/device; mbed/TARGET_NUCLEO_F429ZI/TOOLCHAIN_ARM_STD; mbed/drivers; mbed/hal; mbed/platform;
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-DTRANSACTION_QUEUE_SIZE_SPI=2,-D__CORTEX_M4,-DUSB_STM_HAL,-DARM_MATH_CM4,-D__FPU_PRESENT=1,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_NUCLEO_F429ZI/TOOLCHAIN_ARM_STD/stm32f429xx.sct
  group 
    ./: mbed_config.h main.cpp
  group Actuators
    X_NUCLEO_IKS01A2/ST_INTERFACES/Actuators/: BCDMotor.h StepperMotor.h
  group TARGET_NUCLEO_F429ZI
    mbed/TARGET_NUCLEO_F429ZI/: arm_common_tables.h arm_const_structs.h arm_math.h core_ca9.h core_caFunc.h core_caInstr.h core_ca_mmu.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h
  group TARGET_STM32F4
    mbed/TARGET_NUCLEO_F429ZI/TARGET_STM/TARGET_STM32F4/: common_objects.h device.h i2c_device.h
  group hal
    mbed/hal/: Driver_Common.h Driver_Storage.h analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h emac_api.h ethernet_api.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
  group drivers
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h SPI.h SPISlave.h Serial.h SerialBase.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h
  group DevI2C
    X_NUCLEO_IKS01A2/X_NUCLEO_COMMON/DevI2C/: DevI2C.h
  group platform
    mbed/platform/: CThunk.h CallChain.h Callback.h CircularBuffer.h FunctionPointer.h PlatformMutex.h SingletonPtr.h Transaction.h critical.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_preprocessor.h mbed_stats.h platform.h rtc_time.h semihost_api.h toolchain.h wait_api.h
  group X_NUCLEO_IKS01A2
    X_NUCLEO_IKS01A2/: x_nucleo_iks01a2.h x_nucleo_iks01a2_targets.h x_nucleo_iks01a2.cpp
  group Sensors
    X_NUCLEO_IKS01A2/ST_INTERFACES/Sensors/: GyroSensor.h HumiditySensor.h LightSensor.h MagneticSensor.h MotionSensor.h PressureSensor.h RangeSensor.h TempSensor.h
  group LSM303AGRSensor
    X_NUCLEO_IKS01A2/Components/LSM303AGRSensor/: LSM303AGR_ACC_Sensor.h LSM303AGR_ACC_driver.h LSM303AGR_MAG_Sensor.h LSM303AGR_MAG_driver.h LSM303AGR_ACC_driver.c LSM303AGR_MAG_driver.c LSM303AGR_ACC_Sensor.cpp LSM303AGR_MAG_Sensor.cpp
  group DbgMCU
    X_NUCLEO_IKS01A2/X_NUCLEO_COMMON/DbgMCU/: DbgMCU.h
  group HTS221Sensor
    X_NUCLEO_IKS01A2/Components/HTS221Sensor/: HTS221Sensor.h HTS221_Driver.h HTS221_Driver.c HTS221Sensor.cpp
  group SB1602E
    SB1602E/: SB1602E.h SB1602E.cpp
  group Communications
    X_NUCLEO_IKS01A2/ST_INTERFACES/Communications/: Nfc.h
  group TARGET_STM
    mbed/TARGET_NUCLEO_F429ZI/TARGET_STM/: PeripheralPins.h PinNamesTypes.h PortNames.h gpio_object.h mbed_rtx.h rtc_api_hal.h
  group Common
    X_NUCLEO_IKS01A2/ST_INTERFACES/Common/: ComponentObject.h
  group device
    mbed/TARGET_NUCLEO_F429ZI/TARGET_STM/TARGET_STM32F4/device/: stm32f4xx_hal_flash_ramfunc.h stm32_hal_legacy.h stm32f4xx_hal.h stm32f4xx_hal_adc.h stm32f4xx_hal_adc_ex.h stm32f4xx_hal_can.h stm32f4xx_hal_cec.h stm32f4xx_hal_conf.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_cryp.h stm32f4xx_hal_cryp_ex.h stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.h stm32f4xx_hal_dcmi.h stm32f4xx_hal_dcmi_ex.h stm32f4xx_hal_def.h stm32f4xx_hal_dfsdm.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma2d.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_dsi.h stm32f4xx_hal_eth.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_fmpi2c_ex.h stm32f4xx_hal_fmpi2c.h stm32f4xx_hal_smartcard.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_hash.h stm32f4xx_hal_hash_ex.h stm32f4xx_hal_hcd.h stm32f4xx_hal_i2c.h stm32f4xx_hal_i2c_ex.h stm32f4xx_hal_i2s.h stm32f4xx_hal_i2s_ex.h stm32f4xx_hal_irda.h stm32f4xx_hal_iwdg.h stm32f4xx_hal_lptim.h stm32f4xx_hal_ltdc.h stm32f4xx_hal_ltdc_ex.h stm32f4xx_hal_nand.h stm32f4xx_hal_nor.h stm32f4xx_hal_pccard.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_qspi.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rng.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_sai.h stm32f4xx_hal_sai_ex.h stm32f4xx_hal_sd.h stm32f4xx_hal_sdram.h stm32f4xx_hal_spdifrx.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h stm32f4xx_hal_usart.h stm32f4xx_hal_wwdg.h stm32f4xx_ll_fmc.h stm32f4xx_ll_fsmc.h stm32f4xx_ll_sdmmc.h stm32f4xx_ll_usb.h
  group DevSPI
    X_NUCLEO_IKS01A2/X_NUCLEO_COMMON/DevSPI/: DevSPI.h
  group LPS22HBSensor
    X_NUCLEO_IKS01A2/Components/LPS22HBSensor/: LPS22HBSensor.h LPS22HB_Driver.h LPS22HB_Driver.c LPS22HBSensor.cpp
  group LSM6DSLSensor
    X_NUCLEO_IKS01A2/Components/LSM6DSLSensor/: LSM6DSLSensor.h LSM6DSL_ACC_GYRO_driver.h LSM6DSL_ACC_GYRO_driver.c LSM6DSLSensor.cpp
  group TOOLCHAIN_ARM_STD
    mbed/TARGET_NUCLEO_F429ZI/TOOLCHAIN_ARM_STD/: stm32f4xx_hal_flash_ramfunc.o PeripheralPins.o analogin_api.o analogout_api.o can_api.o cmsis_nvic.o gpio_api.o gpio_irq_api.o hal_init_pre.o hal_tick_16b.o hal_tick_32b.o i2c_api.o lp_ticker.o mbed_board.o mbed_overrides.o pinmap.o port_api.o pwmout_api.o retarget.o rtc_api.o serial_api.o sleep.o spi_api.o startup_stm32f429xx.o stm32f4xx_hal.o stm32f4xx_hal_adc.o stm32f4xx_hal_adc_ex.o stm32f4xx_hal_can.o stm32f4xx_hal_cec.o stm32f4xx_hal_cortex.o stm32f4xx_hal_crc.o stm32f4xx_hal_cryp.o stm32f4xx_hal_cryp_ex.o stm32f4xx_hal_dac.o stm32f4xx_hal_dac_ex.o stm32f4xx_hal_dcmi.o stm32f4xx_hal_dcmi_ex.o stm32f4xx_hal_dfsdm.o stm32f4xx_hal_dma.o stm32f4xx_hal_dma2d.o stm32f4xx_hal_dma_ex.o stm32f4xx_hal_dsi.o stm32f4xx_hal_eth.o stm32f4xx_hal_flash.o stm32f4xx_hal_flash_ex.o stm32f4xx_hal_fmpi2c_ex.o stm32f4xx_hal_fmpi2c.o stm32f4xx_hal_msp_template.o stm32f4xx_hal_gpio.o stm32f4xx_hal_hash.o stm32f4xx_hal_hash_ex.o stm32f4xx_hal_hcd.o stm32f4xx_hal_i2c.o stm32f4xx_hal_i2c_ex.o stm32f4xx_hal_i2s.o stm32f4xx_hal_i2s_ex.o stm32f4xx_hal_irda.o stm32f4xx_hal_iwdg.o stm32f4xx_hal_lptim.o stm32f4xx_hal_ltdc.o stm32f4xx_hal_ltdc_ex.o stm32f4xx_hal_smartcard.o stm32f4xx_hal_nand.o stm32f4xx_hal_nor.o stm32f4xx_hal_pccard.o stm32f4xx_hal_pcd.o stm32f4xx_hal_pcd_ex.o stm32f4xx_hal_pwr.o stm32f4xx_hal_pwr_ex.o stm32f4xx_hal_qspi.o stm32f4xx_hal_rcc.o stm32f4xx_hal_rcc_ex.o stm32f4xx_hal_rng.o stm32f4xx_hal_rtc.o stm32f4xx_hal_rtc_ex.o stm32f4xx_hal_sai.o stm32f4xx_hal_sai_ex.o stm32f4xx_hal_sd.o stm32f4xx_hal_sdram.o stm32f4xx_hal_spdifrx.o stm32f4xx_hal_spi.o stm32f4xx_hal_sram.o stm32f4xx_hal_tim.o stm32f4xx_hal_tim_ex.o stm32f4xx_hal_uart.o stm32f4xx_hal_usart.o stm32f4xx_hal_wwdg.o stm32f4xx_ll_fmc.o stm32f4xx_ll_fsmc.o stm32f4xx_ll_sdmmc.o stm32f4xx_ll_usb.o stm_spi_api.o sys.o system_init_pre.o system_stm32f4xx.o trng_api.o us_ticker_16b.o us_ticker_32b.o mbed.ar
  group mbed
    mbed/: mbed.h
